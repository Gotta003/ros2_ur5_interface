Commit message: changed "tavolo.stl" to "desk.stl"

File: models/model.urdf (robot description, URDF)
Before this commit: robot tavolo, 1 links, 0 joints
Links:
- link link: geometry collision box size=1 0.15 0.15; collision box size=1 0.8 0.04
